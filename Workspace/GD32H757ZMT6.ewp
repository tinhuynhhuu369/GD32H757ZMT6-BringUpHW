# IAR project GD32H757ZMT6.ewp, settings and files
configuration BlinkLed (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GD32H757ZMT6.out
  group 1_Application
    ../1_Application/: main.c
  group 3_Hardware_Core/GD32H73x_75x_standard_peripheral
    ../3_Hardware_Core/GD32H73x_75x_standard_peripheral/Source/: gd32h73x_75x_adc.c gd32h73x_75x_can.c gd32h73x_75x_cau.c gd32h73x_75x_cau_aes.c gd32h73x_75x_cau_des.c gd32h73x_75x_cau_tdes.c gd32h73x_75x_cmp.c gd32h73x_75x_cpdm.c gd32h73x_75x_crc.c gd32h73x_75x_ctc.c gd32h73x_75x_dac.c gd32h73x_75x_dbg.c gd32h73x_75x_dci.c gd32h73x_75x_dma.c gd32h73x_75x_edout.c gd32h73x_75x_efuse.c gd32h73x_75x_enet.c gd32h73x_75x_exmc.c gd32h73x_75x_exti.c gd32h73x_75x_fac.c gd32h73x_75x_fmc.c gd32h73x_75x_fwdgt.c gd32h73x_75x_gpio.c gd32h73x_75x_hau.c gd32h73x_75x_hau_sha_md5.c gd32h73x_75x_hpdf.c gd32h73x_75x_hwsem.c gd32h73x_75x_i2c.c gd32h73x_75x_ipa.c gd32h73x_75x_lpdts.c gd32h73x_75x_mdio.c gd32h73x_75x_mdma.c gd32h73x_75x_misc.c gd32h73x_75x_ospi.c gd32h73x_75x_ospim.c gd32h73x_75x_pmu.c gd32h73x_75x_rameccmu.c gd32h73x_75x_rcu.c gd32h73x_75x_rspdif.c gd32h73x_75x_rtc.c gd32h73x_75x_rtdec.c gd32h73x_75x_sai.c gd32h73x_75x_sdio.c gd32h73x_75x_spi.c gd32h73x_75x_syscfg.c gd32h73x_75x_timer.c gd32h73x_75x_tli.c gd32h73x_75x_tmu.c gd32h73x_75x_trigsel.c gd32h73x_75x_trng.c gd32h73x_75x_usart.c gd32h73x_75x_vref.c gd32h73x_75x_wwdgt.c
  group 3_Hardware_Core/startup
    ../3_Hardware_Core/startup/: gd32h73x_75x_it.c startup_gd32h73x_75x.s system_gd32h73x_75x.c systick.c
